options:
  parameters:
    generate_options: qt_gui
    id: texte
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/rmoulin/4A/BE-Transmission/fichier-recu.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/rmoulin/4A/BE-Transmission/nouveau-fichier.txt
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '16'
    type: byte
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'True'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {state: bypassed}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '2'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: bypassed}
- name: blocks_unpacked_to_packed_xx_1
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '4'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: bypassed}
- name: digital_header_payload_demux_0
  id: digital_header_payload_demux
  parameters:
    header_len: '32'
    header_padding: '0'
    items_per_symbol: '1'
    length_tag_key: '"packet_len"'
    output_symbols: 'False'
    samp_rate: samp_rate
    special_tags: '"packet_len"'
    timing_tag_key: '"rx_time"'
    trigger_tag_key: '"packet_len"'
    type: byte
  states: {}
- name: digital_packet_headergenerator_bb_0
  id: digital_packet_headergenerator_bb
  parameters:
    header_formatter: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: digital_packet_headerparser_b_0
  id: digital_packet_headerparser_b
  parameters:
    header_formatter: '1'
  states: {}
- name: digital_psk_demod_0
  id: digital_psk_demod
  parameters:
    constellation_points: '4'
    differential: 'True'
    excess_bw: '0.35'
    freq_bw: 6.28/100.0
    mod_code: '"gray"'
    phase_bw: 6.28/100.0
    samples_per_symbol: '2'
    timing_bw: 6.28/100.0
  states: {}
- name: digital_psk_mod_0
  id: digital_psk_mod
  parameters:
    constellation_points: '4'
    differential: 'True'
    excess_bw: '0.35'
    mod_code: '"gray"'
    samples_per_symbol: '2'
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_file_source_0, '0', blocks_unpacked_to_packed_xx_1, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_tag_gate_0, '0']
- [blocks_tag_gate_0, '0', digital_packet_headergenerator_bb_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_throttle_0, '0']
- [digital_header_payload_demux_0, '0', digital_packet_headerparser_b_0, '0']
- [digital_header_payload_demux_0, '1', blocks_file_sink_0, '0']
- [digital_packet_headergenerator_bb_0, '0', digital_psk_mod_0, '0']
- [digital_packet_headerparser_b_0, header_data, digital_header_payload_demux_0, header_data]
- [digital_psk_demod_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [digital_psk_demod_0, '0', digital_header_payload_demux_0, '0']
- [digital_psk_mod_0, '0', digital_psk_demod_0, '0']

metadata:
  file_format: 1
