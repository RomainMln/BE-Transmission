options:
  parameters:
    author: rmoulin
    generate_options: qt_gui
    id: manip4
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: constellation
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '2'
    step: '2'
    stop: '64'
    value: '32'
  states: {}
- name: noiseVoltage
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.05'
    stop: '5'
    value: '0'
  states: {}
- name: resamp1
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '2'
    step: '1'
    stop: '128'
    value: '8'
  states: {}
- name: resamp2
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '2'
    step: '1'
    stop: '128'
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: samp_symb1
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '2'
    step: '2'
    stop: '128'
    value: '8'
  states: {}
- name: samp_symb2
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '2'
    step: '2'
    stop: '128'
    value: '8'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/rmoulin/Téléchargements/Céline Dion - Pour que tu maimes encore (Clip officiel).wav
    repeat: 'True'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: noiseVoltage
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: digital_psk_demod_0
  id: digital_psk_demod
  parameters:
    constellation_points: constellation
    differential: 'True'
    excess_bw: '0.35'
    freq_bw: 6.28/100.0
    mod_code: '"gray"'
    phase_bw: 6.28/100.0
    samples_per_symbol: samp_symb2
    timing_bw: 6.28/100.0
  states: {}
- name: digital_psk_mod_0
  id: digital_psk_mod
  parameters:
    constellation_points: constellation
    differential: 'True'
    excess_bw: '0.35'
    mod_code: '"gray"'
    samples_per_symbol: samp_symb1
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '8'
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: vocoder_cvsd_decode_bf_0
  id: vocoder_cvsd_decode_bf
  parameters:
    bw: '0.5'
    resample: resamp2
  states: {}
- name: vocoder_cvsd_encode_fb_0
  id: vocoder_cvsd_encode_fb
  parameters:
    bw: '0.5'
    resample: resamp1
  states: {}

connections:
- [blocks_wavfile_source_0, '0', vocoder_cvsd_encode_fb_0, '0']
- [channels_channel_model_0, '0', digital_psk_demod_0, '0']
- [channels_channel_model_0, '0', qtgui_const_sink_x_0, '0']
- [digital_psk_demod_0, '0', vocoder_cvsd_decode_bf_0, '0']
- [digital_psk_mod_0, '0', channels_channel_model_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [vocoder_cvsd_decode_bf_0, '0', rational_resampler_xxx_0, '0']
- [vocoder_cvsd_encode_fb_0, '0', digital_psk_mod_0, '0']

metadata:
  file_format: 1
