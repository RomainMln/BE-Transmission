options:
  parameters:
    generate_options: qt_gui
    id: RadioPirate
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fc
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 90e6
    step: 100e3
    stop: 110e6
    value: '92600000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10*44100
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: '44100'
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {state: disabled}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: '44100'
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/rmoulin/Téléchargements/Another Day of Sun - La La Land (Original Motion Picture Soundtrack).wav
    repeat: 'True'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: fc
    dev_args: '""'
    gain0: '80'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_nbfm_tx_0, '0', uhd_usrp_sink_0, '0']
- [analog_wfm_tx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_wavfile_source_0, '0', analog_nbfm_tx_0, '0']
- [blocks_wavfile_source_0, '0', analog_wfm_tx_0, '0']

metadata:
  file_format: 1
