options:
  parameters:
    generate_options: qt_gui
    id: GFSK
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Samp_symb
  id: variable
  parameters:
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: variable_0
  id: variable
  parameters:
    value: '0'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/rmoulin/Téléchargements/a-ha - Take On Me (Official Video) [Remastered in 4K].wav
    repeat: 'True'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.0'
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: Samp_symb
    sensitivity: '1.0'
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: Samp_symb
    sensitivity: '1.0'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '8'
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: vocoder_cvsd_decode_bf_0
  id: vocoder_cvsd_decode_bf
  parameters:
    bw: '0.5'
    resample: '8'
  states: {}
- name: vocoder_cvsd_encode_fb_1
  id: vocoder_cvsd_encode_fb
  parameters:
    bw: '0.5'
    resample: '8'
  states: {}

connections:
- [blocks_wavfile_source_0, '0', vocoder_cvsd_encode_fb_1, '0']
- [channels_channel_model_0, '0', digital_gfsk_demod_0, '0']
- [digital_gfsk_demod_0, '0', vocoder_cvsd_decode_bf_0, '0']
- [digital_gfsk_mod_0, '0', channels_channel_model_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [vocoder_cvsd_decode_bf_0, '0', rational_resampler_xxx_0, '0']
- [vocoder_cvsd_encode_fb_1, '0', digital_gfsk_mod_0, '0']

metadata:
  file_format: 1
