options:
  parameters:
    generate_options: qt_gui
    id: RécepteurRadioFM
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq_mod
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 87.5e6
    step: 100e3
    stop: 108e6
    value: 92.6e6
  states: {}
- name: fc_filtre
  id: variable
  parameters:
    value: 40e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '441000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: samp_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: center_freq_mod
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '60'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [uhd_usrp_source_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
