options:
  parameters:
    generate_options: qt_gui
    id: EnvoiTexteSansPaquets
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/rmoulin/4A/BE-Transmission/fichier-recu.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/rmoulin/4A/BE-Transmission/nouveau-fichier.txt
    repeat: 'False'
    type: byte
  states: {}
- name: digital_psk_demod_0
  id: digital_psk_demod
  parameters:
    constellation_points: '4'
    differential: 'True'
    excess_bw: '0.35'
    freq_bw: 6.28/100.0
    mod_code: '"gray"'
    phase_bw: 6.28/100.0
    samples_per_symbol: '2'
    timing_bw: 6.28/100.0
  states: {}
- name: digital_psk_mod_0
  id: digital_psk_mod
  parameters:
    constellation_points: '4'
    differential: 'True'
    excess_bw: '0.35'
    mod_code: '"gray"'
    samples_per_symbol: '2'
  states: {}

connections:
- [blocks_file_source_0, '0', digital_psk_mod_0, '0']
- [digital_psk_demod_0, '0', blocks_file_sink_0, '0']
- [digital_psk_mod_0, '0', digital_psk_demod_0, '0']

metadata:
  file_format: 1
