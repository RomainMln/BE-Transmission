options:
  parameters:
    generate_options: qt_gui
    id: AnalyseurSpectre
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fc
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 100e6
    step: 10e6
    stop: 6e9
    value: 100e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '1024'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: fc
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '80'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
