options:
  parameters:
    generate_options: qt_gui
    id: cfvnb
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: amplitude
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.5'
  states: {state: disabled}
- name: fc
  id: variable
  parameters:
    value: 862e6
  states: {}
- name: fcfiltre
  id: variable
  parameters:
    value: 40e3
  states: {}
- name: freq_signal
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '20'
    step: '1'
    stop: 20e3
    value: 1e3
  states: {state: disabled}
- name: gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '100'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amplitude
    freq: freq_signal
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1'
    offset: '2'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {state: disabled}
- name: audio_sink_0_0_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {state: disabled}
- name: audio_sink_0_0_0_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {state: disabled}
- name: audio_sink_0_0_0_0_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {state: disabled}
- name: audio_sink_0_0_0_0_0_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '100'
    type: float
  states: {state: bypassed}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/rmoulin/Téléchargements/Céline Dion - Pour que tu maimes encore (Clip officiel).wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: /home/rmoulin/Téléchargements/a-ha - Take On Me (Official Video) [Remastered in 4K].wav
    repeat: 'True'
  states: {state: disabled}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '512'
    long_form: 'True'
    type: ff
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: fcfiltre
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 0.1*fcfiltre
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: '44100'
    taps: ''
    type: fff
  states: {state: disabled}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: '44100'
    taps: ''
    type: fff
  states: {state: disabled}
- name: rational_resampler_xxx_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '44100'
    interp: samp_rate
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0_1
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: '44100'
    taps: ''
    type: fff
  states: {state: disabled}
- name: rational_resampler_xxx_0_0_0_1_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: '44100'
    taps: ''
    type: fff
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: fc
    dev_args: '""'
    gain0: '100'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: fc
    dev_args: '""'
    gain0: gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: fc
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', rational_resampler_xxx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_float_0, '0', rational_resampler_xxx_0_0_0_1, '0']
- [blocks_complex_to_float_0, '1', rational_resampler_xxx_0_0_0_1_0, '0']
- [blocks_complex_to_mag_0, '0', low_pass_filter_0, '0']
- [blocks_delay_0, '0', blocks_float_to_complex_0_0, '1']
- [blocks_float_to_complex_0, '0', uhd_usrp_sink_0, '0']
- [blocks_float_to_complex_0_0, '0', rational_resampler_xxx_0_0_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_delay_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0_0, '0']
- [blocks_wavfile_source_0_0, '0', audio_sink_0_0_0_0, '0']
- [dc_blocker_xx_0, '0', rational_resampler_xxx_0_0_0, '0']
- [low_pass_filter_0, '0', dc_blocker_xx_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0_0_0, '0', audio_sink_0_0_0, '0']
- [rational_resampler_xxx_0_0_0_0, '0', blocks_complex_to_float_0, '0']
- [rational_resampler_xxx_0_0_0_0, '0', uhd_usrp_sink_0_0, '0']
- [rational_resampler_xxx_0_0_0_1, '0', audio_sink_0_0_0_0_0, '0']
- [rational_resampler_xxx_0_0_0_1_0, '0', audio_sink_0_0_0_0_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_0, '0']

metadata:
  file_format: 1
